require recipes-core/images/core-image-minimal.bb

SUMMARY = "sample rust layer"
IMAGE_INSTALL += "rust-concurrent-counter"